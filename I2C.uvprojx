# Keil uVision project I2C.uvprojx, settings and files
target hard_I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: I2C
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\cm3;.\CMSIS\system;.\USER;.\FWLIB\inc;.\Device\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ./FWLIB/src/: stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group USER
    ./USER/: main.c
  group Device
    ./Device/src/: usart.c i2c.c
  group CMSIS
    ./CMSIS/cm3/: core_cm3.c
    ./CMSIS/startup/: startup_stm32f10x_md.s
    ./CMSIS/system/: system_stm32f10x.c
